# IAR project Project_06.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: A0handler.c adc.c calibrate.c clocks.c detect.c display.c five_msec_delay.c hex.c hw7.c init.c init_serial.c LCD.r43 LED.c left_forward_off.c left_forward_on.c left_reverse_off.c left_reverse_on.c main.c pfive.c pfour.c ports.c psix.c readme.txt right_forward_off.c right_forward_on.c right_reverse_off.c right_reverse_on.c switch.c system.c timers.c timersA0.c timersB2.r43 USCIhandler.c
